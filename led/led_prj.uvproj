# Keil uVision project led_prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: led_prj
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../Seg7/seg7/: seg7.c seg7.h
